## src/drivers/actuators/dynamixel/Kconfig
```kconfig
menuconfig DRIVERS_ACTUATORS_DYNAMIXEL
	bool "dynamixel"
	default n
	---help---
		Enable Dynamixel Protocol 2.0 actuator output over UART.
```
